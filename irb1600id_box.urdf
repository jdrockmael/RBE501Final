Commit message: Update irb1600id_box.urdf
Added collision geometry

File: irb1600id_box.urdf (robot description, URDF)
Before this commit: robot abb_irb1600id, 9 links, 8 joints
Links:
- link box: geometry collision box size=0.2 0.2 0.2; visual box size=0.2 0.2 0.2
